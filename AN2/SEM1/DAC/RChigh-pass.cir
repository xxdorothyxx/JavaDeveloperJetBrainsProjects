[aimspice]
[description]
79
RC high-pass filter

R1 OUT 0 10k
C1 IN OUT 470n

Vin IN 0 sin(0 5 1k 0 0)
[tran]
1e-6
5e-3
0
X
0
[ana]
4 1
0
1 1
1 1 -6 6
2
v(out)
v(in)
[end]
