[aimspice]
[description]
20
NMOS static invertor
[end]
